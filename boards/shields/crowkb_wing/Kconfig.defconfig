## boards/shields/crowkb_wing/Kconfig.defconfig
```kconfig
if SHIELD_CROWKB_WING

config ZMK_KEYBOARD_NAME
    default "crowkb_wing"

endif
```
